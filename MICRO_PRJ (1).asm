ORG 0000H
HERE:
SETB P2.0
ACALL ON1
CLR P2.0
SETB P2.1
ACALL ON2
CLR P2.1
ACALL OFF
SJMP HERE

ON1:
MOV TMOD,#01H
MOV TH0,#0FAH
MOV TL0,#09AH
SETB TR0
LOOP: JNB TF0,LOOP
CLR TR0
CLR TF0
RET

ON2:
MOV TMOD,#01H
MOV TH0,#0F7H
MOV TL0,#000H
SETB TR0
LOOP1: JNB TF0,LOOP1
CLR TR0
CLR TF0
RET

OFF:
MOV TMOD,#01H                 //1ST OFF-2ND ON
MOV TH0,#0C6H                 // FFFF-2ND ON   + 1ST OFF
MOV TL0,#065H
SETB TR0
LOOP2: JNB TF0,LOOP2
CLR TR0
CLR TF0
RET
end